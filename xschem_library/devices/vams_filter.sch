v {xschem version=3.4.8 file_version=1.2
* Verilog-AMS filtering example.
}
G {}
V {}
S {}
E {}
C {res.sym} 0 0 0 0 {name=R1 value=1k}
C {nmos4.sym} 0 100 0 0 {name=M1 model=nmos w=1u l=1u}
C {vams_mixed_io.sym} 0 200 0 0 {name=U1}
C {title.sym} 0 300 0 0 {name=t1 author="AMS filter"}
