v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {vams_mixed_io.sym} -10 0 0 0 {name=U1}
